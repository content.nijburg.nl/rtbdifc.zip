Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 22728088-ad6a-4409-a6de-d8ee264010f3, NumberOfSaves: 31]
File name: Project Number
Time: 2024-01-17T14:26:28+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_1677119_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRS_57_AIR_UN_swirl diffuser rtbd LT_sacs:550, NLRS_57_AIR_UN_swirl diffuser rtbd LT_sacs:550:1677119
In: Default
Type - Description: Swirl supply grill, Type RTBD; PredefinedType: DIFFUSER; Material: RAL9010, Sendzimir verzinkt
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_swirl diffuser rtbd LT_sacs; SACS_Base_Index: 4
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - SACS_Plenum_B: 578 mm
Type - General - Lookup_Grill_Factors: Grill_Selection_Factors; SACS_Article_Data: RTBD_data; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 04-04-2022; SACS_Revision_Number: 3.19.02
Type - Identity Data - Assembly Code: 57; Cost: 0; Description: Swirl supply grill, Type RTBD; Manufacturer: Solid Air Climate Solutions; Model: RTBD; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 04-04-2022; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.02; NLRS_C_description: Swirl supply grill, Type RTBD; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Comments: Please make sure flow is set to m3/h!; Type Name: 550; URL: https://solid-air.nl/producten/solid-air-plafondroosters-rtbd-rrbd/
Type - Mechanical - Flow - Max Flow: 250 dm3/s; Min Flow: 80 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 550; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_swirl diffuser rtbd LT_sacs; Family and Type: NLRS_57_AIR_UN_swirl diffuser rtbd LT_sacs: 550; Type: 550; Type Id: 1676801
Model Properties - SACS_Color_Ral: yes; SACS_Connector_Top: yes; SACS_Lined_Plenum: no; SACS_Low_Plenum: no; SACS_Option_1: RTBD; SACS_Option_2: OA; SACS_Oval_Connector: no; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - NLRS_M_c01_diameter: 250 mm; SACS_Plenum_Height: 160 mm; Volume: 0.00110762 m3
Identity Data - Mark: 7317; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: RTBDOA 550; SACS_Article_Code: 8201000003; SACS_Gross_Cost: 174; SACS_Price_Date: 01-02-2022
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Color: RAL9010; SACS_Lining_Thickness: 0 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; SACS_Primairy_Air_Temperature: 15 C; SACS_Room_Temperature: 25 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Cooling_Capacity: 0 W; SACS_Heating_Capacity: 0 W; SACS_Lp_dBA: 0; SACS_Throw: 0 mm
Phasing - Phase Created: New Construction
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Throw_Visible: yes; SACS_Warning_Disable: no
